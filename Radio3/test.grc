options:
  parameters:
    author: gabri
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: button
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.323e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: button
    type: byte
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '8'
    minimum: '1'
    seed: '0'
    type: int
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: int
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sample_and_hold_xx_0, '1']
- [analog_random_uniform_source_x_0, '0', blocks_sample_and_hold_xx_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sample_and_hold_xx_0, '0', blocks_int_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
