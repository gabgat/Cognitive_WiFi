options:
  parameters:
    generate_options: qt_gui
    id: Radio2
    output_language: python
    title: Radio 2 - Reciever
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '2429500000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '0.0'
    sample_rate: samp_rate
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    packet_len_key: '"length"'
    payload_mod: '"BPSK"'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '45000000'
    center_freq0: frequency
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0, '0', blocks_uchar_to_float_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
